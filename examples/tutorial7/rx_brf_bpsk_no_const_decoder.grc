options:
  parameters:
    author: root
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bits_per_chunk
  id: variable
  parameters:
    value: int(math.log2(arity))
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: math.log2(arity)
  states: {}
- name: chunks_per_byte
  id: variable
  parameters:
    value: int(8/bits_per_chunk)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1,1]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 1000e6
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: samp_rate * chunks_per_byte * rrc_interpolation
  states: {}
- name: rrc_interpolation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rrc_taps_rx
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Receiver_gain
    start: '0.0'
    step: '1'
    stop: '100'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '4'
    step_size: '100e-6'
    type: cma
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'True'
    bias_tee1: 'False'
    bw: 2e6
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '0'
    dc_offset_mode1: '0'
    device_id: '0'
    fpga_image: ''
    fpga_reload: 'False'
    freq: rf_freq
    gain0: rx_gain
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_rate: samp_rate * chunks_per_byte * rrc_interpolation
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'False'
    verbosity: verbose
    xb200: none
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: 4M bits/sec
    k: bits_per_chunk
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      2M symbols/sec
      (1 symbol / sample)
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity*2
    w: phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    comment: |-
      2M symbols/sec
      (1 symbol / sample)
    num_taps: '15'
    sps: '2'
    training_sequence: '[]'
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: |-
      2M symbols / sec
      4M samples / sec
      (2 symbols / sample)
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: rrc_interpolation
    taps: rrc_taps_rx
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5e6
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: note_0_0_0_0_0_0_0_0_0_0_0
  id: note
  parameters:
    note: 8 samp_rate
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: 8 samp_rate
  states: {}
- name: note_0_0_1_0
  id: note
  parameters:
    note: 4 samp_rate
  states: {}
- name: note_0_0_1_0_0
  id: note
  parameters:
    note: 4 samp_rate
  states: {}
- name: note_0_0_1_0_0_0
  id: note
  parameters:
    note: 4 samp_rate
  states: {}
- name: note_0_0_1_0_0_0_0
  id: note
  parameters:
    note: 8 samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    label1: rx
    name: '"Rx Raw"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    label1: rx
    name: '"After Freq Corr"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate * chunks_per_byte * rrc_interpolation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Symbols
    label2: ''
    name: Rx Raw  Signal
    size: '500'
    srate: samp_rate * chunks_per_byte * rrc_interpolation
    type: complex
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: Rx Bits
    name: Received Bits
    size: '500'
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Re
    label2: Im
    label3: Symbol
    name: '"Decoded Symbols"'
    nconnections: '3'
    size: '500'
    srate: samp_rate
    style1: '2'
    style2: '4'
    type: float
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    label1: Symbols
    label2: ''
    name: After Poly Phase
    size: '500'
    srate: samp_rate * chunks_per_byte * 2
    type: complex
    ymax: '4'
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: received_signal
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: |-
      4M sample per sec
      samp_rate * chunks_per_byte * Interpolation
      125K         * 4                        * 8
    stream_id: received_signal
  states: {}

connections:
- [bladeRF_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [bladeRF_source_0, '0', low_pass_filter_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1, '2']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_1, '1']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_time_sink_x_0_2, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_2, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
