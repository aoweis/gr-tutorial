options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: bpsk_rx_pkt
    output_language: python
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bytes_per_chunk
  id: variable
  parameters:
    value: '8'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {}
- name: eq_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,1,1,1'
    label: 'Equalizer: rate'
    start: '0.0'
    step: '0.001'
    stop: '0.1'
    value: '0.01'
    widget: slider
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,1,1,1'
    label: Frequency Offset
    start: '-0.1'
    step: '0.001'
    stop: '0.1'
    value: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_crc
    value: digital.header_format_crc(len_key, num_key)
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,0,1,1'
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0001'
  states: {}
- name: num_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,2,1,1'
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1,1]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    start: '2479'
    step: '.001'
    stop: '2481'
    value: '2480'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: samp_rate* sps * bytes_per_chunk
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '.1'
    stop: '30'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@0: 0,2,1,1'
    label: Timing Offset
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.00'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    gui_hint: 'controls@1: 0,0,1,1'
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: qpsk
    modulus: '1'
    step_size: '.0001'
    type: cma
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: bladeRF_source_0
  id: bladeRF_source
  parameters:
    bias_tee0: 'True'
    bias_tee1: 'False'
    bw: rf_samp_rate
    dac: '10000'
    dc_calibration: LPF_TUNING
    dc_offset_mode0: '2'
    dc_offset_mode1: '0'
    device_id: '0'
    fpga_image: ''
    fpga_reload: 'False'
    freq: rf_freq * 1e6 - 250e3
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    in_clk: ONBOARD
    iq_balance_mode0: '0'
    iq_balance_mode1: '0'
    lpf_mode: disabled
    metadata: 'False'
    nchan: '1'
    out_clk: 'False'
    ref_clk: 10e6
    sample_rate: rf_samp_rate
    sampling: internal
    show_pmic: 'False'
    smb: '0'
    tamer: internal
    trigger0: 'False'
    trigger1: 'False'
    trigger_role0: master
    trigger_role1: master
    trigger_signal0: J51_1
    trigger_signal1: J51_1
    use_dac: 'False'
    use_ref_clk: 'True'
    verbosity: debug
    xb200: none
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-250e3'
    sample_rate: rf_samp_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '1'
  states: {}
- name: controls
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,2
    label0: Channel
    label1: Receiver
    num_tabs: '2'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '32'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len"'
    output_symbols: 'False'
    samp_rate: int(samp_rate)
    special_tags: ()
    timing_tag_key: '"burst"'
    trigger_tag_key: '"packet_len"'
    type: byte
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
    training_sequence: '[]'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1]'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '0.05'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 'received@0: 0,0,1,1'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rf_samp_rate
    fc: rf_freq
    fftsize: '1024'
    name: '"blade Out"'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'received@1: 0,0,1,1'
    label1: Symbols
    name: ''
    size: '500'
    srate: samp_rate * bytes_per_chunk
    type: float
    ymax: '4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: Rx Bits
    name: ''
    size: '500'
    srate: samp_rate * bytes_per_chunk
    type: float
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"out of bladerf"'
    size: '1024'
    srate: rf_samp_rate
    type: complex
  states: {}
- name: received
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,1,1
    label0: Constellation
    label1: Symbols
    num_tabs: '2'
  states: {}

connections:
- [analog_agc3_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_agc3_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc3_xx_0, '0', qtgui_time_sink_x_1_0, '0']
- [bladeRF_source_0, '0', blocks_freqshift_cc_0, '0']
- [bladeRF_source_0, '0', qtgui_sink_x_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_freqshift_cc_0, '0', analog_agc3_xx_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_repack_bits_bb_1_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_header_payload_demux_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_probe_rate_0, '0']
- [digital_header_payload_demux_0, '0', digital_protocol_parser_b_0, '0']
- [digital_header_payload_demux_0, '1', blocks_repack_bits_bb_1_0, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
